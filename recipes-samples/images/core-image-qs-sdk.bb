require recipes-sato/images/core-image-sato-sdk.bb
require core-image-qs.inc
IMAGE_INSTALL += "liboqs-dev"

