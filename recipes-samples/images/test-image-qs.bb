require recipes-sato/images/core-image-sato.bb

require core-image-qs.inc

IMAGE_BASENAME = "${PN}"

